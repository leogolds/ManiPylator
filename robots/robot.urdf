Commit message: basic control example works!

File: robots/robot.urdf (robot description, URDF)
Before this commit: robot onshape, 7 links, 6 joints
Links:
- removed link end_effector
Joints:
- removed joint wrist_3
